COMPATIBLE_MACHINE_append = "|sopine-a64"

KBUILD_DEFCONFIG_sopine-a64 = "defconfig"

